VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

LAYER OVERLAP
  TYPE OVERLAP ;
END OVERLAP

END LIBRARY
