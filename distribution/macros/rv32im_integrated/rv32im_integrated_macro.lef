###############################################################
#  Generated by:      Cadence Innovus 21.35-s114_1
#  OS:                Linux x86_64(Host ID pc231.ee.hacettepe.edu.tr)
#  Generated on:      Thu Dec 25 09:54:04 2025
#  Design:            rv32im_integrated_macro
#  Command:           write_lef_abstract -5.7 outputs/rv32im_integrated/rv32im_integrated_macro.lef
###############################################################

VERSION 5.7 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO rv32im_integrated_macro
  CLASS BLOCK ;
  SIZE 1309.440000 BY 809.930000 ;
  FOREIGN rv32im_integrated_macro 0.000000 0.000000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN clk
    DIRECTION INPUT ;
    USE SIGNAL ;
  END clk
  PIN rst_n
    DIRECTION INPUT ;
    USE SIGNAL ;
  END rst_n
  PIN iwb_adr_o[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[31]
  PIN iwb_adr_o[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[30]
  PIN iwb_adr_o[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[29]
  PIN iwb_adr_o[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[28]
  PIN iwb_adr_o[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[27]
  PIN iwb_adr_o[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[26]
  PIN iwb_adr_o[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[25]
  PIN iwb_adr_o[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[24]
  PIN iwb_adr_o[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[23]
  PIN iwb_adr_o[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[22]
  PIN iwb_adr_o[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[21]
  PIN iwb_adr_o[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[20]
  PIN iwb_adr_o[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[19]
  PIN iwb_adr_o[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[18]
  PIN iwb_adr_o[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[17]
  PIN iwb_adr_o[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[16]
  PIN iwb_adr_o[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[15]
  PIN iwb_adr_o[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[14]
  PIN iwb_adr_o[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[13]
  PIN iwb_adr_o[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[12]
  PIN iwb_adr_o[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[11]
  PIN iwb_adr_o[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[10]
  PIN iwb_adr_o[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[9]
  PIN iwb_adr_o[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[8]
  PIN iwb_adr_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[7]
  PIN iwb_adr_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[6]
  PIN iwb_adr_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[5]
  PIN iwb_adr_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[4]
  PIN iwb_adr_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[3]
  PIN iwb_adr_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[2]
  PIN iwb_adr_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[1]
  PIN iwb_adr_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_adr_o[0]
  PIN iwb_dat_i[31]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[31]
  PIN iwb_dat_i[30]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[30]
  PIN iwb_dat_i[29]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[29]
  PIN iwb_dat_i[28]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[28]
  PIN iwb_dat_i[27]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[27]
  PIN iwb_dat_i[26]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[26]
  PIN iwb_dat_i[25]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[25]
  PIN iwb_dat_i[24]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[24]
  PIN iwb_dat_i[23]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[23]
  PIN iwb_dat_i[22]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[22]
  PIN iwb_dat_i[21]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[21]
  PIN iwb_dat_i[20]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[20]
  PIN iwb_dat_i[19]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[19]
  PIN iwb_dat_i[18]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[18]
  PIN iwb_dat_i[17]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[17]
  PIN iwb_dat_i[16]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[16]
  PIN iwb_dat_i[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[15]
  PIN iwb_dat_i[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[14]
  PIN iwb_dat_i[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[13]
  PIN iwb_dat_i[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[12]
  PIN iwb_dat_i[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[11]
  PIN iwb_dat_i[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[10]
  PIN iwb_dat_i[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[9]
  PIN iwb_dat_i[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[8]
  PIN iwb_dat_i[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[7]
  PIN iwb_dat_i[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[6]
  PIN iwb_dat_i[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[5]
  PIN iwb_dat_i[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[4]
  PIN iwb_dat_i[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[3]
  PIN iwb_dat_i[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[2]
  PIN iwb_dat_i[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[1]
  PIN iwb_dat_i[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_dat_i[0]
  PIN iwb_cyc_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_cyc_o
  PIN iwb_stb_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END iwb_stb_o
  PIN iwb_ack_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END iwb_ack_i
  PIN dwb_adr_o[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[31]
  PIN dwb_adr_o[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[30]
  PIN dwb_adr_o[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[29]
  PIN dwb_adr_o[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[28]
  PIN dwb_adr_o[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[27]
  PIN dwb_adr_o[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[26]
  PIN dwb_adr_o[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[25]
  PIN dwb_adr_o[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[24]
  PIN dwb_adr_o[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[23]
  PIN dwb_adr_o[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[22]
  PIN dwb_adr_o[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[21]
  PIN dwb_adr_o[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[20]
  PIN dwb_adr_o[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[19]
  PIN dwb_adr_o[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[18]
  PIN dwb_adr_o[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[17]
  PIN dwb_adr_o[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[16]
  PIN dwb_adr_o[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[15]
  PIN dwb_adr_o[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[14]
  PIN dwb_adr_o[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[13]
  PIN dwb_adr_o[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[12]
  PIN dwb_adr_o[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[11]
  PIN dwb_adr_o[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[10]
  PIN dwb_adr_o[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[9]
  PIN dwb_adr_o[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[8]
  PIN dwb_adr_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[7]
  PIN dwb_adr_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[6]
  PIN dwb_adr_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[5]
  PIN dwb_adr_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[4]
  PIN dwb_adr_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[3]
  PIN dwb_adr_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[2]
  PIN dwb_adr_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[1]
  PIN dwb_adr_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_adr_o[0]
  PIN dwb_dat_o[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[31]
  PIN dwb_dat_o[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[30]
  PIN dwb_dat_o[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[29]
  PIN dwb_dat_o[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[28]
  PIN dwb_dat_o[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[27]
  PIN dwb_dat_o[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[26]
  PIN dwb_dat_o[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[25]
  PIN dwb_dat_o[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[24]
  PIN dwb_dat_o[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[23]
  PIN dwb_dat_o[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[22]
  PIN dwb_dat_o[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[21]
  PIN dwb_dat_o[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[20]
  PIN dwb_dat_o[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[19]
  PIN dwb_dat_o[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[18]
  PIN dwb_dat_o[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[17]
  PIN dwb_dat_o[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[16]
  PIN dwb_dat_o[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[15]
  PIN dwb_dat_o[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[14]
  PIN dwb_dat_o[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[13]
  PIN dwb_dat_o[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[12]
  PIN dwb_dat_o[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[11]
  PIN dwb_dat_o[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[10]
  PIN dwb_dat_o[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[9]
  PIN dwb_dat_o[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[8]
  PIN dwb_dat_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[7]
  PIN dwb_dat_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[6]
  PIN dwb_dat_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[5]
  PIN dwb_dat_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[4]
  PIN dwb_dat_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[3]
  PIN dwb_dat_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[2]
  PIN dwb_dat_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[1]
  PIN dwb_dat_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_dat_o[0]
  PIN dwb_dat_i[31]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[31]
  PIN dwb_dat_i[30]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[30]
  PIN dwb_dat_i[29]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[29]
  PIN dwb_dat_i[28]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[28]
  PIN dwb_dat_i[27]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[27]
  PIN dwb_dat_i[26]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[26]
  PIN dwb_dat_i[25]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[25]
  PIN dwb_dat_i[24]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[24]
  PIN dwb_dat_i[23]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[23]
  PIN dwb_dat_i[22]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[22]
  PIN dwb_dat_i[21]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[21]
  PIN dwb_dat_i[20]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[20]
  PIN dwb_dat_i[19]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[19]
  PIN dwb_dat_i[18]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[18]
  PIN dwb_dat_i[17]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[17]
  PIN dwb_dat_i[16]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[16]
  PIN dwb_dat_i[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[15]
  PIN dwb_dat_i[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[14]
  PIN dwb_dat_i[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[13]
  PIN dwb_dat_i[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[12]
  PIN dwb_dat_i[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[11]
  PIN dwb_dat_i[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[10]
  PIN dwb_dat_i[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[9]
  PIN dwb_dat_i[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[8]
  PIN dwb_dat_i[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[7]
  PIN dwb_dat_i[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[6]
  PIN dwb_dat_i[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[5]
  PIN dwb_dat_i[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[4]
  PIN dwb_dat_i[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[3]
  PIN dwb_dat_i[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[2]
  PIN dwb_dat_i[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[1]
  PIN dwb_dat_i[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_dat_i[0]
  PIN dwb_we_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_we_o
  PIN dwb_sel_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_sel_o[3]
  PIN dwb_sel_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_sel_o[2]
  PIN dwb_sel_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_sel_o[1]
  PIN dwb_sel_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_sel_o[0]
  PIN dwb_cyc_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_cyc_o
  PIN dwb_stb_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END dwb_stb_o
  PIN dwb_ack_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_ack_i
  PIN dwb_err_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END dwb_err_i
  PIN interrupts[31]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[31]
  PIN interrupts[30]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[30]
  PIN interrupts[29]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[29]
  PIN interrupts[28]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[28]
  PIN interrupts[27]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[27]
  PIN interrupts[26]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[26]
  PIN interrupts[25]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[25]
  PIN interrupts[24]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[24]
  PIN interrupts[23]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[23]
  PIN interrupts[22]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[22]
  PIN interrupts[21]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[21]
  PIN interrupts[20]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[20]
  PIN interrupts[19]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[19]
  PIN interrupts[18]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[18]
  PIN interrupts[17]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[17]
  PIN interrupts[16]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[16]
  PIN interrupts[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[15]
  PIN interrupts[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[14]
  PIN interrupts[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[13]
  PIN interrupts[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[12]
  PIN interrupts[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[11]
  PIN interrupts[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[10]
  PIN interrupts[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[9]
  PIN interrupts[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[8]
  PIN interrupts[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[7]
  PIN interrupts[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[6]
  PIN interrupts[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[5]
  PIN interrupts[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[4]
  PIN interrupts[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[3]
  PIN interrupts[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[2]
  PIN interrupts[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[1]
  PIN interrupts[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END interrupts[0]
  OBS
    LAYER met1 ;
      RECT 0.000000 0.000000 1309.440000 809.930000 ;
    LAYER met2 ;
      RECT 0.000000 0.000000 1309.440000 809.930000 ;
    LAYER met3 ;
      RECT 0.000000 0.000000 1309.440000 809.930000 ;
    LAYER met4 ;
      RECT 0.000000 0.000000 1309.440000 809.930000 ;
    LAYER met5 ;
      RECT 0.000000 0.000000 1309.440000 809.930000 ;
  END
END rv32im_integrated_macro

END LIBRARY
