###############################################################
#  Generated by:      Cadence Innovus 21.35-s114_1
#  OS:                Linux x86_64(Host ID pc231.ee.hacettepe.edu.tr)
#  Generated on:      Thu Dec 25 15:19:02 2025
#  Design:            rv32im_soc_with_integrated_core
#  Command:           write_lef_abstract outputs/soc_integrated/rv32im_soc_with_integrated_core.lef
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO rv32im_soc_with_integrated_core
  CLASS BLOCK ;
  SIZE 2240.160000 BY 2239.980000 ;
  FOREIGN rv32im_soc_with_integrated_core 0.000000 0.000000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN clk
    DIRECTION INPUT ;
    USE SIGNAL ;
  END clk
  PIN rst_n
    DIRECTION INPUT ;
    USE SIGNAL ;
  END rst_n
  PIN ext_mem_adr_o[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[31]
  PIN ext_mem_adr_o[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[30]
  PIN ext_mem_adr_o[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[29]
  PIN ext_mem_adr_o[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[28]
  PIN ext_mem_adr_o[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[27]
  PIN ext_mem_adr_o[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[26]
  PIN ext_mem_adr_o[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[25]
  PIN ext_mem_adr_o[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[24]
  PIN ext_mem_adr_o[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[23]
  PIN ext_mem_adr_o[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[22]
  PIN ext_mem_adr_o[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[21]
  PIN ext_mem_adr_o[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[20]
  PIN ext_mem_adr_o[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[19]
  PIN ext_mem_adr_o[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[18]
  PIN ext_mem_adr_o[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[17]
  PIN ext_mem_adr_o[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[16]
  PIN ext_mem_adr_o[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[15]
  PIN ext_mem_adr_o[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[14]
  PIN ext_mem_adr_o[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[13]
  PIN ext_mem_adr_o[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[12]
  PIN ext_mem_adr_o[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[11]
  PIN ext_mem_adr_o[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[10]
  PIN ext_mem_adr_o[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[9]
  PIN ext_mem_adr_o[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[8]
  PIN ext_mem_adr_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[7]
  PIN ext_mem_adr_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[6]
  PIN ext_mem_adr_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[5]
  PIN ext_mem_adr_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[4]
  PIN ext_mem_adr_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[3]
  PIN ext_mem_adr_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[2]
  PIN ext_mem_adr_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[1]
  PIN ext_mem_adr_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_adr_o[0]
  PIN ext_mem_dat_o[31]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[31]
  PIN ext_mem_dat_o[30]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[30]
  PIN ext_mem_dat_o[29]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[29]
  PIN ext_mem_dat_o[28]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[28]
  PIN ext_mem_dat_o[27]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[27]
  PIN ext_mem_dat_o[26]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[26]
  PIN ext_mem_dat_o[25]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[25]
  PIN ext_mem_dat_o[24]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[24]
  PIN ext_mem_dat_o[23]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[23]
  PIN ext_mem_dat_o[22]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[22]
  PIN ext_mem_dat_o[21]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[21]
  PIN ext_mem_dat_o[20]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[20]
  PIN ext_mem_dat_o[19]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[19]
  PIN ext_mem_dat_o[18]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[18]
  PIN ext_mem_dat_o[17]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[17]
  PIN ext_mem_dat_o[16]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[16]
  PIN ext_mem_dat_o[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[15]
  PIN ext_mem_dat_o[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[14]
  PIN ext_mem_dat_o[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[13]
  PIN ext_mem_dat_o[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[12]
  PIN ext_mem_dat_o[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[11]
  PIN ext_mem_dat_o[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[10]
  PIN ext_mem_dat_o[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[9]
  PIN ext_mem_dat_o[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[8]
  PIN ext_mem_dat_o[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[7]
  PIN ext_mem_dat_o[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[6]
  PIN ext_mem_dat_o[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[5]
  PIN ext_mem_dat_o[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[4]
  PIN ext_mem_dat_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[3]
  PIN ext_mem_dat_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[2]
  PIN ext_mem_dat_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[1]
  PIN ext_mem_dat_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_dat_o[0]
  PIN ext_mem_dat_i[31]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[31]
  PIN ext_mem_dat_i[30]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[30]
  PIN ext_mem_dat_i[29]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[29]
  PIN ext_mem_dat_i[28]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[28]
  PIN ext_mem_dat_i[27]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[27]
  PIN ext_mem_dat_i[26]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[26]
  PIN ext_mem_dat_i[25]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[25]
  PIN ext_mem_dat_i[24]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[24]
  PIN ext_mem_dat_i[23]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[23]
  PIN ext_mem_dat_i[22]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[22]
  PIN ext_mem_dat_i[21]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[21]
  PIN ext_mem_dat_i[20]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[20]
  PIN ext_mem_dat_i[19]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[19]
  PIN ext_mem_dat_i[18]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[18]
  PIN ext_mem_dat_i[17]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[17]
  PIN ext_mem_dat_i[16]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[16]
  PIN ext_mem_dat_i[15]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[15]
  PIN ext_mem_dat_i[14]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[14]
  PIN ext_mem_dat_i[13]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[13]
  PIN ext_mem_dat_i[12]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[12]
  PIN ext_mem_dat_i[11]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[11]
  PIN ext_mem_dat_i[10]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[10]
  PIN ext_mem_dat_i[9]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[9]
  PIN ext_mem_dat_i[8]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[8]
  PIN ext_mem_dat_i[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[7]
  PIN ext_mem_dat_i[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[6]
  PIN ext_mem_dat_i[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[5]
  PIN ext_mem_dat_i[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[4]
  PIN ext_mem_dat_i[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[3]
  PIN ext_mem_dat_i[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[2]
  PIN ext_mem_dat_i[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[1]
  PIN ext_mem_dat_i[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_dat_i[0]
  PIN ext_mem_we_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_we_o
  PIN ext_mem_sel_o[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_sel_o[3]
  PIN ext_mem_sel_o[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_sel_o[2]
  PIN ext_mem_sel_o[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_sel_o[1]
  PIN ext_mem_sel_o[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_sel_o[0]
  PIN ext_mem_cyc_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_cyc_o
  PIN ext_mem_stb_o
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ext_mem_stb_o
  PIN ext_mem_ack_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_ack_i
  PIN ext_mem_err_i
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_mem_err_i
  PIN uart_tx
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END uart_tx
  PIN uart_rx
    DIRECTION INPUT ;
    USE SIGNAL ;
  END uart_rx
  PIN spi_sclk
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END spi_sclk
  PIN spi_mosi
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END spi_mosi
  PIN spi_miso
    DIRECTION INPUT ;
    USE SIGNAL ;
  END spi_miso
  PIN spi_cs_n
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END spi_cs_n
  PIN gpio[15]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[15]
  PIN gpio[14]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[14]
  PIN gpio[13]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[13]
  PIN gpio[12]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[12]
  PIN gpio[11]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[11]
  PIN gpio[10]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[10]
  PIN gpio[9]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[9]
  PIN gpio[8]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[8]
  PIN gpio[7]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[7]
  PIN gpio[6]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[6]
  PIN gpio[5]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[5]
  PIN gpio[4]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[4]
  PIN gpio[3]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[3]
  PIN gpio[2]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[2]
  PIN gpio[1]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[1]
  PIN gpio[0]
    DIRECTION INOUT ;
    USE SIGNAL ;
  END gpio[0]
  PIN pwm_out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[7]
  PIN pwm_out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[6]
  PIN pwm_out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[5]
  PIN pwm_out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[4]
  PIN pwm_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[3]
  PIN pwm_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[2]
  PIN pwm_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[1]
  PIN pwm_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out[0]
  PIN pwm_out_n[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[7]
  PIN pwm_out_n[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[6]
  PIN pwm_out_n[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[5]
  PIN pwm_out_n[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[4]
  PIN pwm_out_n[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[3]
  PIN pwm_out_n[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[2]
  PIN pwm_out_n[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[1]
  PIN pwm_out_n[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END pwm_out_n[0]
  PIN adc_data_in[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END adc_data_in[3]
  PIN adc_data_in[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END adc_data_in[2]
  PIN adc_data_in[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END adc_data_in[1]
  PIN adc_data_in[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END adc_data_in[0]
  PIN adc_clk_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_clk_out[3]
  PIN adc_clk_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_clk_out[2]
  PIN adc_clk_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_clk_out[1]
  PIN adc_clk_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_clk_out[0]
  PIN ch0_data[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[15]
  PIN ch0_data[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[14]
  PIN ch0_data[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[13]
  PIN ch0_data[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[12]
  PIN ch0_data[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[11]
  PIN ch0_data[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[10]
  PIN ch0_data[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[9]
  PIN ch0_data[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[8]
  PIN ch0_data[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[7]
  PIN ch0_data[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[6]
  PIN ch0_data[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[5]
  PIN ch0_data[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[4]
  PIN ch0_data[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[3]
  PIN ch0_data[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[2]
  PIN ch0_data[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[1]
  PIN ch0_data[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch0_data[0]
  PIN ch1_data[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[15]
  PIN ch1_data[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[14]
  PIN ch1_data[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[13]
  PIN ch1_data[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[12]
  PIN ch1_data[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[11]
  PIN ch1_data[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[10]
  PIN ch1_data[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[9]
  PIN ch1_data[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[8]
  PIN ch1_data[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[7]
  PIN ch1_data[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[6]
  PIN ch1_data[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[5]
  PIN ch1_data[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[4]
  PIN ch1_data[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[3]
  PIN ch1_data[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[2]
  PIN ch1_data[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[1]
  PIN ch1_data[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch1_data[0]
  PIN ch2_data[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[15]
  PIN ch2_data[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[14]
  PIN ch2_data[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[13]
  PIN ch2_data[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[12]
  PIN ch2_data[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[11]
  PIN ch2_data[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[10]
  PIN ch2_data[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[9]
  PIN ch2_data[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[8]
  PIN ch2_data[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[7]
  PIN ch2_data[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[6]
  PIN ch2_data[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[5]
  PIN ch2_data[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[4]
  PIN ch2_data[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[3]
  PIN ch2_data[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[2]
  PIN ch2_data[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[1]
  PIN ch2_data[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch2_data[0]
  PIN ch3_data[15]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[15]
  PIN ch3_data[14]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[14]
  PIN ch3_data[13]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[13]
  PIN ch3_data[12]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[12]
  PIN ch3_data[11]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[11]
  PIN ch3_data[10]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[10]
  PIN ch3_data[9]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[9]
  PIN ch3_data[8]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[8]
  PIN ch3_data[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[7]
  PIN ch3_data[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[6]
  PIN ch3_data[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[5]
  PIN ch3_data[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[4]
  PIN ch3_data[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[3]
  PIN ch3_data[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[2]
  PIN ch3_data[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[1]
  PIN ch3_data[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END ch3_data[0]
  PIN adc_data_valid[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_data_valid[3]
  PIN adc_data_valid[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_data_valid[2]
  PIN adc_data_valid[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_data_valid[1]
  PIN adc_data_valid[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END adc_data_valid[0]
  PIN current_sense[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END current_sense[3]
  PIN current_sense[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END current_sense[2]
  PIN current_sense[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END current_sense[1]
  PIN current_sense[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END current_sense[0]
  PIN voltage_sense[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END voltage_sense[3]
  PIN voltage_sense[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END voltage_sense[2]
  PIN voltage_sense[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END voltage_sense[1]
  PIN voltage_sense[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END voltage_sense[0]
  PIN thermal_alert_in
    DIRECTION INPUT ;
    USE SIGNAL ;
  END thermal_alert_in
  PIN emergency_stop
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END emergency_stop
  PIN channel_disable[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END channel_disable[3]
  PIN channel_disable[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END channel_disable[2]
  PIN channel_disable[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END channel_disable[1]
  PIN channel_disable[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END channel_disable[0]
  PIN system_reset
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END system_reset
  PIN watchdog_timeout
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END watchdog_timeout
  PIN timer_interrupt
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END timer_interrupt
  PIN timer_compare_out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END timer_compare_out[3]
  PIN timer_compare_out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END timer_compare_out[2]
  PIN timer_compare_out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END timer_compare_out[1]
  PIN timer_compare_out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END timer_compare_out[0]
  PIN ext_interrupts[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[7]
  PIN ext_interrupts[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[6]
  PIN ext_interrupts[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[5]
  PIN ext_interrupts[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[4]
  PIN ext_interrupts[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[3]
  PIN ext_interrupts[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[2]
  PIN ext_interrupts[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[1]
  PIN ext_interrupts[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END ext_interrupts[0]
  OBS
    LAYER met1 ;
      RECT 0.000000 0.000000 2240.160000 2239.980000 ;
    LAYER met2 ;
      RECT 0.000000 0.000000 2240.160000 2239.980000 ;
    LAYER met3 ;
      RECT 0.000000 0.000000 2240.160000 2239.980000 ;
    LAYER met4 ;
      RECT 0.000000 0.000000 2240.160000 2239.980000 ;
    LAYER met5 ;
      RECT 0.000000 0.000000 2240.160000 2239.980000 ;
  END
END rv32im_soc_with_integrated_core

END LIBRARY
